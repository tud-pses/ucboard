# Repository tud-pses/ucboard

File README.md:

# ucboard
Firmware for the µController used in the pses robot.

For a more in depth documentation of the project,
please read the provided ucboard.pdf file in the repository.

You can also browse through the [wiki](https://github.com/tud-pses/ucboard/wiki) of this repository.

## KiCad design kicad_ucboard/ucboard.kicad_pcb

Parts:
C1, C16, C17, C37: 4u7; C_1206_HandSoldering; Part No. 1828835
C2, C6, C20, C23: 1u; C_0603_HandSoldering; Part No. 2346901
C3, C5, C7, C9, C10, C15, C26, C27, C28, C30, C31, C32, C33, C34, C35, C36, C38, C39: 100n; C_0603_HandSoldering
C4, C8, C29: 10n; C_0603_HandSoldering
C11, C12: 27p; C_0805_HandSoldering; Part No. 7568584
C13, C19: n.b.; C_0603_HandSoldering
C14, C22: 1m; C_Radial_D10_L20_P5-7.5; Part No. 2469429
C18, C24, C25, C40, C41, C43, C44, C45, C46, C47, C48, C49, C50: n.B.; C_0603_HandSoldering
C21: 470n; C_0603_HandSoldering
D1, D3: 2mA, gn; LED_0603_HandSoldering
D2, D4, D5: 2mA, re; LED_0603_HandSoldering
D6: 2mA, or; LED_0603_HandSoldering
IC1: FT232RL; SSOP-28_5.3x10.2mm_Pitch0.65mm; Part No. 1146032
L1: 8u2; SRN6045; Part No. 2061651
L2, L3: FB 600R; R_0805_HandSoldering
P1: Powerpath In; PS25_5G; Part No. PS25_5G
P2: PWM_SERVO; Pin_Header_Straight_1x03
P3: PWM_DRIVE; Pin_Header_Straight_1x02
P4: BATT2_IN; WAGO_713-1423; Part No. WAGO 713-1423
P5: ADC12; IDC_Header_Straight_6pins; Part No. WSL 6G
P6: BATT2_REG_OUT; WAGO_713-1423; Part No. WAGO 713-1423
P7: Timer1; Pin_Header_Straight_1x03
P8: Timer3; Pin_Header_Straight_1x03
P9: Hal5; Pin_Header_Straight_1x04
P10: BATTERY 2; PS25_3G; Part No. PS25 3G
P11: Timer8; Pin_Header_Straight_1x05
P12: Timer20; Pin_Header_Straight_1x05
P13: USB_B; Part No. USB BW
P14: CAR-ID; SW_DIP_x4_Slide; Part No. NT 04
P15: JTAG; IDC_Header_Straight_20pins; Part No. WSL 20G
P16: DIO; Pin_Header_Straight_2x06
P17: ADC; Pin_Header_Straight_2x05
P18: MPU-9250_EXT; Pin_Header_Straight_1x07
P19: SFR08_I2C; Pin_Header_Straight_1x05
P20: I2C2; IDC_Header_Straight_8pins
P21: I2C3; IDC_Header_Straight_8pins
P22: Serial Port; IDC_Header_Straight_10pins; Part No. WSL 10G
P23, P24: 5V; Pin_Header_Straight_2x02
P25: 3.3V; Pin_Header_Straight_2x02
P26: UART4; Pin_Header_Straight_2x03
P27: SPI2; IDC_Header_Straight_14pins; Part No. WSL 14G
P28: SPI4; IDC_Header_Straight_14pins; Part No. WSL 14G
P29: 5V_Servo; Pin_Header_Straight_2x02
PD2, PD3, PD4, PD5, PD6: Hole; MountingHole_3.3mm_M3
Q1, Q4, Q5: IRLML9301; SOT-23_Handsoldering; Part No. 1831089
Q2, Q3, Q6: IRLML6344; SOT-23_Handsoldering; Part No. 1857299
R1, R5, R8, R18, R20, R46, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R62: 0R; R_0603_HandSoldering
R2: 470R; R_0603_HandSoldering
R3, R15, R16, R19, R21, R24, R26, R28, R30, R33, R34, R35, R36, R37, R61, R65, R66: n.B.; R_0603_HandSoldering
R4, R11, R12, R13, R14, R17, R25, R27, R31, R38, R39, R40, R42, R67, R68: 10k; R_0603_HandSoldering
R6, R22: 56k; R_0603_HandSoldering
R7, R43, R44, R45, R49, R60: 680R; R_0603_HandSoldering
R9, R10, R63, R64: 100R; R_0603_HandSoldering
R23: 11k; R_0603_HandSoldering
R29: 27k; R_0603_HandSoldering
R32: 2k7; R_0603_HandSoldering
R41: 4k7; R_0603_HandSoldering
R47, R48: n.b.; R_0603_HandSoldering
SW1: RESET; BUTTON; Part No. TASTER 9314
SW2: Button1; BUTTON; Part No. TASTER 9314
SW3: Button2; BUTTON; Part No. TASTER 9314
SW4: Button3; BUTTON; Part No. TASTER 9314
U1: STM32F303VE; LQFP100_14x14mm; Part No. 497-15164-ND
U2: TEN_30-1212; TEN30; Part No. 1772204
U3: MCP6054; SOIC-14_3.9x8.7mm_Pitch1.27mm; Part No. 1715855
U4, U5: TSR_1-2450; TSR1; Part No. 1696320
U6: LD1117_S33TR; SOT-223; Part No. 1202826
U7: MPU-9250; Part No. 1428-1019-1-ND
U8: MAX3232; SOIC-16_3.9x9.9mm_Pitch1.27mm; Part No. 1564957
U9: 25LC160A-I/SN; SOIC-8_3.9x4.9mm_Pitch1.27mm; Part No. 1084340
Y1: 8MHz; HC-49S_Crystal; Part No. 1842347

Connections:
+3V3: C1.1, C3.1, C5.1, C7.1, C9.1, C15.1, C27.1, C29.1, C30.1, C39.1, D5.2 (A), L3.1, P15.1, P15.2, P16.9, P20.5, P21.5, P25.1, P25.2, P27.11, P28.11, Q4.2 (S), R12.2, U1.6 (VBAT), U1.28 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD), U6.2 (+Vout), U6.4 (+Vout), U7.1 (RESV_VDDIO), U7.8 (VDDIO), U7.13 (VDD), U8.16 (VCC), U9.8 (Vcc)
+5V: C20.1, C31.1, C36.1, C37.1, IC1.20 (VCC), P5.4, P7.2, P8.2, P9.1, P11.4, P12.4, P16.10, P17.8, P18.1, P19.1, P20.6, P21.6, P23.1, P23.2, P24.1, P24.2, P27.12, P28.12, U5.3 (+Vout), U6.3 (+Vin)
+12V: P6.5, P6.6, U2.4 (+Vout)
/ADC4_IN1: R57.2, U1.45 (PE14)
/ADC4_IN2: R58.2, U1.46 (PE15)
/ADC12_IN6: R28.2, U1.15 (PC0)
/ADC12_IN7: R37.2, U1.16 (PC1)
/BATT2_+V_MEAS: C19.1, P10.1, Q5.2 (S), R25.2
/BATT2_-V_MEAS: L2.1, P10.2
/BOOT0: R48.2, R67.2, U1.94 (BOOT0)
/BUTTON1: SW2.1, U1.7 (PC13)
/BUTTON2: SW3.1, U1.8 (OSC32_IN-PC14)
/BUTTON3: SW4.1, U1.9 (OSC32_OUT-PC15)
/CAR_ID_1: P14.8, U1.19 (PF2)
/CAR_ID_2: P14.7, U1.73 (PF6)
/CAR_ID_3: P14.6, U1.10 (PF9)
/CAR_ID_4: P14.5, U1.11 (PF10)
/CTL_12V: Q2.1 (G), R4.1, R7.1, U1.42 (PE11)
/CTL_BATT2_OUT: P10.3, U1.66 (PC9)
/CTL_MEAS_V1: Q3.1 (G), R13.1, U1.38 (PE7)
/CTL_MEAS_V2: Q6.1 (G), R27.1, U1.39 (PE8)
/EEPROM_HOLD: U1.44 (PE13), U9.7 (~HOLD)
/EEPROM_WP: U1.41 (PE10), U9.3 (~WP)
/I2C1_SCL: P19.3, U1.92 (PB6)
/I2C1_SDA: P19.2, U1.93 (PB7)
/I2C2_SCL: P20.1, P20.2, U1.68 (PA9)
/I2C2_SDA: P20.3, P20.4, U1.69 (PA10)
/I2C3_SCL: P21.1, P21.2, U1.67 (PA8)
/I2C3_SDA: P21.3, P21.4, U1.91 (PB5)
/JTCK: P15.9, U1.76 (PA14)
/JTDI: P15.5, U1.77 (PA15)
/JTDO: P15.13, U1.89 (PB3)
/JTMS: P15.7, U1.72 (PA13)
/JTRST: P15.3, U1.90 (PB4)
/LED1: R43.1, U1.33 (PC4)
/LED2: R44.1, U1.34 (PC5)
/LED3: R45.1, U1.65 (PC8)
/LED4: R60.1, U1.70 (PA11)
/MPU_INT: R53.1, R65.2, U1.62 (PD15)
/PB1: P11.3, U1.36 (PB1)
/PB2: P12.3, U1.37 (PB2)
/PD0: P16.1, U1.81 (PD0)
/PD1: P16.3, U1.82 (PD1)
/PD2: P16.5, U1.83 (PD2)
/PD3: P16.7, U1.84 (PD3)
/PD4: P16.2, U1.85 (PD4)
/PD5: P16.4, U1.86 (PD5)
/PD6: P16.6, U1.87 (PD6)
/PD7: P16.8, U1.88 (PD7)
/PD10: C44.2, R55.2, U1.57 (PD10)
/PD11: C45.1, R56.2, U1.58 (PD11)
/PD12: C43.1, R54.2, U1.59 (PD12)
/PD13: C41.2, R51.2, U1.60 (PD13)
/PD14: C40.1, R52.2, U1.61 (PD14)
/PPC_+V: P1.2, R3.1
/PPC_+V_MEAS: C13.1, P1.3, Q1.2 (S), R11.2
/PPC_+V_PWR: P4.1, P4.2, R8.1, U2.1 (+Vin(Vcc))
/PPC_-V: P1.1, R5.1, R66.1
/PPC_Akkuwng: P1.5, U1.80 (PC12)
/PPC_NetzOk: P1.4, U1.71 (PA12)
/RESET#: C10.2, P15.15, R47.2, SW1.1, U1.14 (NRST)
/SPI1_CS1: U1.29 (PA4), U7.22 (nCS)
/SPI1_CS2: U1.35 (PB0), U9.1 (~CS)
/SPI1_CS3: P18.6, U1.95 (PB8)
/SPI1_MISO: P18.7, U1.31 (PA6), U7.9 (AD0/SDO), U9.2 (MISO)
/SPI1_MOSI: P18.4, U1.32 (PA7), U7.24 (SDA/SDI), U9.5 (MOSI)
/SPI1_SCK: P18.3, U1.30 (PA5), U7.23 (SCL/SCLK), U9.6 (SCK)
/SPI2_CS1: P27.8, U1.96 (PB9)
/SPI2_CS2: P27.10, U1.47 (PB10)
/SPI2_CS3: P27.7, U1.48 (PB11)
/SPI2_CS4: P27.9, U1.51 (PB12)
/SPI2_MISO: P27.3, P27.4, U1.53 (PB14)
/SPI2_MOSI: P27.5, P27.6, U1.54 (PB15)
/SPI2_SCK: P27.1, P27.2, U1.52 (PB13)
/SPI4_CS1: P28.8, U1.97 (PE0)
/SPI4_CS2: P28.10, U1.98 (PE1)
/SPI4_CS3: P28.7, U1.2 (PE3)
/SPI4_CS4: P28.9, U1.3 (PE4)
/SPI4_MISO: P28.3, P28.4, U1.4 (PE5)
/SPI4_MOSI: P28.5, P28.6, U1.5 (PE6)
/SPI4_SCK: P28.1, P28.2, U1.43 (PE12)
/TIM1_CH1: P7.1, U1.40 (PE9)
/TIM1_CH3: P12.1, U1.17 (PC2)
/TIM1_CH4: P12.2, U1.18 (PC3)
/TIM2_CH1: R9.2, U1.23 (PA0)
/TIM2_CH2: R10.2, U1.24 (PA1)
/TIM3_CH1: P8.1, U1.1 (PE2)
/TIM8_CH1: P11.1, U1.63 (PC6)
/TIM8_CH2: P11.2, U1.64 (PC7)
/UART4_RX: P26.1, P26.2, U1.79 (PC11)
/UART4_TX: P26.3, P26.4, U1.78 (PC10)
/USART2_RX: R63.2, U1.26 (PA3)
/USART2_TX: R64.2, U1.25 (PA2)
/USART3_RX: U1.56 (PD9), U8.12 (ROUT1)
/USART3_TX: U1.55 (PD8), U8.11 (DIN1)
/USBDNEG: IC1.16 (USBDM), P13.2 (D-)
/USBDPOS: IC1.15 (USBDP), P13.3 (D+)
/uC_VDDA: C2.1, C4.1, C6.1, C8.1, P5.3, P9.4, P17.7, R26.2, R36.2, R59.1, R68.2, U1.21 (VREF+), U1.22 (VDDA), U3.4 (V+)
GND: C1.2, C3.2, C5.2, C7.2, C9.2, C10.1, C11.1, C12.2, C20.2, C27.2, C29.2, C30.2, C31.2, C32.1, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D6.1 (K), IC1.7 (GND), IC1.18 (GND), IC1.21 (GND), IC1.25 (AGND), IC1.26 (TEST), P2.3, P3.2, P7.3, P8.3, P11.5, P12.5, P13.4 (GND), P14.1, P14.2, P14.3, P14.4, P15.4, P15.6, P15.8, P15.10, P15.12, P15.14, P15.16, P15.18, P15.20, P16.11, P16.12, P18.2, P19.5, P20.7, P20.8, P21.7, P21.8, P22.5, P23.3, P23.4, P24.3, P24.4, P25.3, P25.4, P26.5, P26.6, P27.13, P27.14, P28.13, P28.14, P29.3, P29.4, Q2.2 (S), R1.2, R4.2, R5.2, R18.1, R38.1, R39.1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
GNDA: C2.2, C4.2, C6.2, C8.2, C21.2, C24.2, C40.2, C41.1, C43.2, C44.1, C45.2, C46.2, C47.1, C48.1, P5.5, P5.6, P9.2, P17.9, P17.10, Q3.2 (S), Q6.2 (S), R1.1, R13.2, R17.2, R20.2, R21.2, R23.2, R27.2, R31.2, R34.2, R66.2, U1.20 (VSSA), U3.11 (V-)
GNDPWR: C14.2, C16.2, C17.2, C22.2, C23.2, C26.2, P4.3, P4.4, P6.3, P6.4, R14.2, R18.2, U2.2 (-Vin(GND)), U2.5 (-Vout), U4.2 (GND), U5.2 (GND)
unnamed: C11.2, U1.12 (OSC_IN-PF0), Y1.2
unnamed: C12.1, R2.1, Y1.1
unnamed: C13.2, Q1.1 (G), Q3.3 (D), R11.1
unnamed: C14.1, C16.1, L1.1, R3.2, R8.2
unnamed: C15.2, Q2.3 (D), Q4.1 (G), R12.1
unnamed: C17.1, L1.2, U4.1 (+Vin), U5.1 (+Vin)
unnamed: C18.1, C49.2, R19.2, R21.1, R24.1, U3.2 (-)
unnamed: C18.2, R24.2, R28.1, U3.1
unnamed: C19.2, Q5.1 (G), Q6.3 (D), R25.1
unnamed: C21.1, R29.2, U3.5 (+)
unnamed: C24.1, R32.2, U3.12 (+)
unnamed: C25.1, C50.2, R33.2, R34.1, R35.1, U3.9 (-)
unnamed: C25.2, R35.2, R37.1, U3.8
unnamed: C28.1, U8.1 (C1+)
unnamed: C28.2, U8.3 (C1-)
unnamed: C32.2, U8.2 (V+)
unnamed: C33.1, U8.4 (C2+)
unnamed: C33.2, U8.5 (C2-)
unnamed: C34.1, U7.10 (REGOUT)
unnamed: C35.1, U8.6 (V-)
unnamed: C38.1, IC1.4 (VCCIO), IC1.17 (3V3OUT)
unnamed: C46.1, L3.2, R59.2
unnamed: C47.2, R15.1, U3.3 (+)
unnamed: C48.2, R61.1, U3.10 (+)
unnamed: C49.1, R15.2, R16.2, R17.1, R26.1
unnamed: C50.1, R30.2, R31.1, R36.1, R61.2
unnamed: D1.2 (A), R7.2
unnamed: D2.2 (A), R43.2
unnamed: D3.2 (A), R44.2
unnamed: D4.2 (A), R45.2
unnamed: D5.1 (K), R49.2
unnamed: D6.2 (A), R60.2
unnamed: IC1.1 (TXD), R63.1
unnamed: IC1.2 (DTR#), R48.1
unnamed: IC1.3 (RTS#), R47.1
unnamed: IC1.5 (RXD), R64.1
unnamed: IC1.19 (RESET#), R41.2, R42.1
unnamed: IC1.23 (CBUS0), R49.1
unnamed: L2.2, R20.1
unnamed: P2.1, R9.1
unnamed: P3.1, R10.1
unnamed: P5.1, R16.1, R19.1
unnamed: P5.2, R30.1, R33.1
unnamed: P9.3, R32.1, R68.1
unnamed: P13.1 (VCC), R41.1
unnamed: P13.5 (shield), R62.1
unnamed: P15.11, R38.2
unnamed: P15.17, R39.2
unnamed: P15.19, R40.2
unnamed: P17.1, R51.1
unnamed: P17.2, R55.1
unnamed: P17.3, R52.1
unnamed: P17.4, R56.1
unnamed: P17.6, R54.1
unnamed: P18.5, R65.1
unnamed: P22.1, R46.1
unnamed: P22.2, U8.14 (DOUT1)
unnamed: P22.3, U8.13 (RIN1)
unnamed: P22.6, R50.1
unnamed: P22.7, P22.8
unnamed: Q1.3 (D), R6.1
unnamed: Q4.3 (D), R14.1, U2.3 (Remote_On/Off)
unnamed: Q5.3 (D), R22.1
unnamed: R2.2, U1.13 (OSC_OUT-PF1)
unnamed: R6.2, R22.2, R23.1, R29.1
unnamed: R46.2, R50.2, U8.7 (DOUT2)
unnamed: R53.2, U7.12 (INT)
unnamed: R57.1, U3.6 (-), U3.7
unnamed: R58.1, U3.13 (-), U3.14
SERVO_+5V: C22.1, C23.1, C26.1, P2.2, P29.1, P29.2, U4.3 (+Vout)

Notes on the sheet:
USB-UART-Wandler
RS232-UART-Wandler
Batteriespannungsmessung
Spannungsversorgung
MPU-9250 SPI Accelerometer-Gyroskop-Magnetometer
MPU-9250 SPI Extern
Zusätzliche Timer Ausgänge
PWM Ausgänge Lenkservos und Antriebsmotor
Ultraschallsensoren I2C
Hallsensor Analog
Zusätzliche I2C
Zusätzliche SPI
Car-ID Einstellung
Zusätzliche GPIO
JTAG
Spannungsversorgung Kinect 12V
5V Tolerant
EEPROM
Externe Op-Amps
Taster
Zusätzliche Spannungsversorgung
UART
Verdeckt
Status LEDs
Zusätzliche GPIO Analog

Board: 2 copper layers, 140.0 x 140.0 mm, 180 parts (24 on the bottom side), 171 nets.

## KiCad design kicad_SchalterFahrakku/Schalter_Fahrakku.kicad_pcb

Parts:
C1: 100n; C_0603_HandSoldering
C2: 470n; C_0603_HandSoldering
D1: LED; LED_0603_HandSoldering
P1: V_IN+; Pad_SMD_3.5x10
P2: V_IN-; Pad_SMD_3.5x10
P3: uC_IN; PS25_3W; Part No. PS 25/3W BR
P4: V_OUT+; Pad_SMD_3.5x10
P5: V_OUT-; Pad_SMD_3.5x10
PD1, PD2: Hole; MountingHole_3.3mm_M3
PD3, PD4, PD5, PD6, PD7, PD8, PD9, PD10, PD11, PD12, PD13, PD14, PD15, PD16, PD17, PD18: Hole; Hole_3mm
Q1: IRLML6344; SOT-23; Part No. 1857299
Q2: IPD90P03; TO-252-2Lead; Part No. 2480839
R1, R2: 10k; R_0603_HandSoldering
R3: 3k6; R_0603_HandSoldering

Connections:
/CTL_DRIVE: C1.1, P3.3, Q1.1 (G), R1.1
GND: C1.2, D1.1, P2.1, P3.2, P5.1, Q1.2 (S), R1.2
unnamed: C2.1, P1.1, P3.1, Q2.3 (S), R2.1
unnamed: C2.2, Q1.3 (D), Q2.1 (G), R2.2
unnamed: D1.2, R3.2
unnamed: P4.1, Q2.2 (D), R3.1

Board: 2 copper layers, 55.0 x 25.0 mm, 31 parts (0 on the bottom side), 6 nets.

## Code that names these connections

File fw_workspace/pses_ucboard/pses_ucboard.ioc (part):

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Mcu.Name=STM32F303V(D-E)Tx
Mcu.Package=LQFP100
Mcu.UserName=STM32F303VETx
PA0.Signal=S_TIM2_CH1_ETR
PA1.Signal=S_TIM2_CH2
PA10.Mode=I2C
PA10.Signal=I2C2_SDA
PA11.Signal=GPIO_Output
PA12.GPIOParameters=GPIO_PuPd
PA12.GPIO_PuPd=GPIO_PULLUP
PA12.Signal=GPIO_Input
PA13.Mode=JTAG_5_pins
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=JTAG_5_pins
PA14.Signal=SYS_JTCK-SWCLK
PA15.Mode=JTAG_5_pins
PA15.Signal=SYS_JTDI
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.Signal=GPIO_Output
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.Mode=I2C
PA8.Signal=I2C3_SCL
PA9.Mode=I2C
PA9.Signal=I2C2_SCL
PB0.Signal=GPIO_Output
PB1.Signal=GPXTI1
PB10.Signal=GPIO_Output
PB11.Signal=GPIO_Output
PB12.Signal=GPIO_Output
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB2.Signal=GPXTI2
PB3.Mode=JTAG_5_pins
PB3.Signal=SYS_JTDO-TRACESWO
PB4.Mode=JTAG_5_pins
PB4.Signal=SYS_NJTRST
PB5.Mode=I2C
PB5.Signal=I2C3_SDA
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PB8.Signal=GPIO_Output
PB9.Signal=GPIO_Output
PC0.Signal=ADCx_IN6
PC1.Signal=ADCx_IN7
PC10.Mode=Asynchronous
PC10.Signal=UART4_TX
PC11.Mode=Asynchronous
PC11.Signal=UART4_RX
PC12.GPIOParameters=GPIO_PuPd
PC12.GPIO_PuPd=GPIO_PULLUP
PC12.Signal=GPIO_Input
PC13.GPIOParameters=GPIO_PuPd
PC13.GPIO_PuPd=GPIO_PULLUP
PC13.Signal=GPIO_Input
PC14-OSC32_IN.GPIOParameters=GPIO_PuPd
PC14-OSC32_IN.GPIO_PuPd=GPIO_PULLUP
PC14-OSC32_IN.Signal=GPIO_Input
PC15-OSC32_OUT.GPIOParameters=GPIO_PuPd
PC15-OSC32_OUT.GPIO_PuPd=GPIO_PULLUP
PC15-OSC32_OUT.Signal=GPIO_Input
PC2.Signal=S_TIM1_CH3
PC3.Signal=S_TIM1_CH4
PC4.Signal=GPIO_Output
PC5.Signal=GPIO_Output
PC6.Signal=S_TIM8_CH1
PC7.Signal=S_TIM8_CH2
PC8.Signal=GPIO_Output
PC9.Signal=GPIO_Output
PD0.Signal=GPIO_Input
PD1.Signal=GPIO_Input
PD10.Signal=ADCx_IN7P
PD11.Signal=ADCx_IN8P
PD12.Signal=ADCx_IN9P
PD13.Signal=ADCx_IN10P
PD14.Signal=ADCx_IN11
PD15.Signal=GPXTI15
PD2.Signal=GPIO_Input
PD3.Signal=GPIO_Input
PD4.Signal=GPIO_Input
PD5.Signal=GPIO_Input
PD6.Signal=GPIO_Input
PD7.Signal=GPIO_Input
PD8.Mode=Asynchronous
PD8.Signal=USART3_TX
PD9.Mode=Asynchronous
PD9.Signal=USART3_RX
PE0.Signal=GPIO_Output
PE1.Signal=GPIO_Output
PE10.Signal=GPIO_Output
PE11.Signal=GPIO_Output
PE12.Mode=Full_Duplex_Master
PE12.Signal=SPI4_SCK
PE13.Signal=GPIO_Output
PE14.Mode=IN1-Single-Ended
PE14.Signal=ADC4_IN1
PE15.Mode=IN2-Single-Ended
PE15.Signal=ADC4_IN2
PE2.Signal=S_TIM3_CH1
PE3.Signal=GPIO_Output
PE4.Signal=GPIO_Output
PE5.Mode=Full_Duplex_Master
PE5.Signal=SPI4_MISO
PE6.Mode=Full_Duplex_Master
PE6.Signal=SPI4_MOSI
PE7.Signal=GPIO_Output
PE8.Signal=GPIO_Output
PE9.Signal=S_TIM1_CH1
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
PF10.GPIOParameters=GPIO_PuPd
PF10.GPIO_PuPd=GPIO_PULLUP
PF10.Signal=GPIO_Input
PF2.GPIOParameters=GPIO_PuPd
PF2.GPIO_PuPd=GPIO_PULLUP
PF2.Signal=GPIO_Input
PF6.GPIOParameters=GPIO_PuPd
PF6.GPIO_PuPd=GPIO_PULLUP
PF6.Signal=GPIO_Input
PF9.GPIOParameters=GPIO_PuPd
PF9.GPIO_PuPd=GPIO_PULLUP
PF9.Signal=GPIO_Input
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=8000000
board=pses_ucboard

File fw_workspace/pses_ucboard/Src/stm32f3xx_hal_msp.c (part):

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    __HAL_RCC_ADC12_CLK_ENABLE();
  
    /**ADC1 GPIO Configuration    
    PC0     ------> ADC1_IN6
    PC1     ------> ADC1_IN7 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_0|GPIO_PIN_1;
    GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
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    }
  
    /**ADC3 GPIO Configuration    
    PD10     ------> ADC3_IN7
    PD11     ------> ADC3_IN8
    PD12     ------> ADC3_IN9 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_10|GPIO_PIN_11|GPIO_PIN_12;
    GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
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    }
  
    /**ADC4 GPIO Configuration    
    PE14     ------> ADC4_IN1
    PE15     ------> ADC4_IN2
    PD13     ------> ADC4_IN10
    PD14     ------> ADC4_IN11 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_14|GPIO_PIN_15;
    GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
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    __HAL_RCC_ADC12_CLK_DISABLE();
  
    /**ADC1 GPIO Configuration    
    PC0     ------> ADC1_IN6
    PC1     ------> ADC1_IN7 
    */
    HAL_GPIO_DeInit(GPIOC, GPIO_PIN_0|GPIO_PIN_1);

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    }
  
    /**ADC3 GPIO Configuration    
    PD10     ------> ADC3_IN7
    PD11     ------> ADC3_IN8
    PD12     ------> ADC3_IN9 
    */
    HAL_GPIO_DeInit(GPIOD, GPIO_PIN_10|GPIO_PIN_11|GPIO_PIN_12);

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    }
  
    /**ADC4 GPIO Configuration    
    PE14     ------> ADC4_IN1
    PE15     ------> ADC4_IN2
    PD13     ------> ADC4_IN10
    PD14     ------> ADC4_IN11 
    */
    HAL_GPIO_DeInit(GPIOE, GPIO_PIN_14|GPIO_PIN_15);

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  /* USER CODE END I2C1_MspInit 0 */
  
    /**I2C1 GPIO Configuration    
    PB6     ------> I2C1_SCL
    PB7     ------> I2C1_SDA 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_6|GPIO_PIN_7;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_OD;
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  /* USER CODE END I2C2_MspInit 0 */
  
    /**I2C2 GPIO Configuration    
    PA9     ------> I2C2_SCL
    PA10     ------> I2C2_SDA 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_9|GPIO_PIN_10;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_OD;
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  /* USER CODE END I2C3_MspInit 0 */
  
    /**I2C3 GPIO Configuration    
    PA8     ------> I2C3_SCL
    PB5     ------> I2C3_SDA 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_8;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_OD;
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    __HAL_RCC_I2C1_CLK_DISABLE();
  
    /**I2C1 GPIO Configuration    
    PB6     ------> I2C1_SCL
    PB7     ------> I2C1_SDA 
    */
    HAL_GPIO_DeInit(GPIOB, GPIO_PIN_6|GPIO_PIN_7);

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    __HAL_RCC_I2C2_CLK_DISABLE();
  
    /**I2C2 GPIO Configuration    
    PA9     ------> I2C2_SCL
    PA10     ------> I2C2_SDA 
    */
    HAL_GPIO_DeInit(GPIOA, GPIO_PIN_9|GPIO_PIN_10);

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    __HAL_RCC_I2C3_CLK_DISABLE();
  
    /**I2C3 GPIO Configuration    
    PA8     ------> I2C3_SCL
    PB5     ------> I2C3_SDA 
    */
    HAL_GPIO_DeInit(GPIOA, GPIO_PIN_8);

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    __HAL_RCC_SPI1_CLK_ENABLE();
  
    /**SPI1 GPIO Configuration    
    PA5     ------> SPI1_SCK
    PA6     ------> SPI1_MISO
    PA7     ------> SPI1_MOSI 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_5|GPIO_PIN_6|GPIO_PIN_7;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
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    __HAL_RCC_SPI2_CLK_ENABLE();
  
    /**SPI2 GPIO Configuration    
    PB13     ------> SPI2_SCK
    PB14     ------> SPI2_MISO
    PB15     ------> SPI2_MOSI 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_13|GPIO_PIN_14|GPIO_PIN_15;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
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    __HAL_RCC_SPI4_CLK_ENABLE();
  
    /**SPI4 GPIO Configuration    
    PE5     ------> SPI4_MISO
    PE6     ------> SPI4_MOSI
    PE12     ------> SPI4_SCK 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_5|GPIO_PIN_6|GPIO_PIN_12;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
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    __HAL_RCC_SPI1_CLK_DISABLE();
  
    /**SPI1 GPIO Configuration    
    PA5     ------> SPI1_SCK
    PA6     ------> SPI1_MISO
    PA7     ------> SPI1_MOSI 
    */
    HAL_GPIO_DeInit(GPIOA, GPIO_PIN_5|GPIO_PIN_6|GPIO_PIN_7);

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    __HAL_RCC_SPI2_CLK_DISABLE();
  
    /**SPI2 GPIO Configuration    
    PB13     ------> SPI2_SCK
    PB14     ------> SPI2_MISO
    PB15     ------> SPI2_MOSI 
    */
    HAL_GPIO_DeInit(GPIOB, GPIO_PIN_13|GPIO_PIN_14|GPIO_PIN_15);

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    __HAL_RCC_SPI4_CLK_DISABLE();
  
    /**SPI4 GPIO Configuration    
    PE5     ------> SPI4_MISO
    PE6     ------> SPI4_MOSI
    PE12     ------> SPI4_SCK 
    */
    HAL_GPIO_DeInit(GPIOE, GPIO_PIN_5|GPIO_PIN_6|GPIO_PIN_12);

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
  /* USER CODE END TIM1_MspPostInit 0 */
    /**TIM1 GPIO Configuration    
    PC2     ------> TIM1_CH3
    PC3     ------> TIM1_CH4
    PE9     ------> TIM1_CH1 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_2|GPIO_PIN_3;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
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  /* USER CODE END TIM2_MspPostInit 0 */
  
    /**TIM2 GPIO Configuration    
    PA0     ------> TIM2_CH1
    PA1     ------> TIM2_CH2 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_0|GPIO_PIN_1;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
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  /* USER CODE END TIM3_MspPostInit 0 */
  
    /**TIM3 GPIO Configuration    
    PE2     ------> TIM3_CH1 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_2;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
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  /* USER CODE END TIM8_MspPostInit 0 */
  
    /**TIM8 GPIO Configuration    
    PC6     ------> TIM8_CH1
    PC7     ------> TIM8_CH2 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_6|GPIO_PIN_7;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
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    __HAL_RCC_UART4_CLK_ENABLE();
  
    /**UART4 GPIO Configuration    
    PC10     ------> UART4_TX
    PC11     ------> UART4_RX 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_10|GPIO_PIN_11;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
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    __HAL_RCC_USART2_CLK_ENABLE();
  
    /**USART2 GPIO Configuration    
    PA2     ------> USART2_TX
    PA3     ------> USART2_RX 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_2|GPIO_PIN_3;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
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    __HAL_RCC_USART3_CLK_ENABLE();
  
    /**USART3 GPIO Configuration    
    PD8     ------> USART3_TX
    PD9     ------> USART3_RX 
    */
    GPIO_InitStruct.Pin = GPIO_PIN_8|GPIO_PIN_9;
    GPIO_InitStruct.Mode = GPIO_MODE_AF_PP;
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    __HAL_RCC_UART4_CLK_DISABLE();
  
    /**UART4 GPIO Configuration    
    PC10     ------> UART4_TX
    PC11     ------> UART4_RX 
    */
    HAL_GPIO_DeInit(GPIOC, GPIO_PIN_10|GPIO_PIN_11);

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    __HAL_RCC_USART2_CLK_DISABLE();
  
    /**USART2 GPIO Configuration    
    PA2     ------> USART2_TX
    PA3     ------> USART2_RX 
    */
    HAL_GPIO_DeInit(GPIOA, GPIO_PIN_2|GPIO_PIN_3);

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    __HAL_RCC_USART3_CLK_DISABLE();
  
    /**USART3 GPIO Configuration    
    PD8     ------> USART3_TX
    PD9     ------> USART3_RX 
    */
    HAL_GPIO_DeInit(GPIOD, GPIO_PIN_8|GPIO_PIN_9);

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
## Commit log (part)

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2016-08-18 Aktueller Stand von Andreas Jentsch in Repository eingecheckt
2016-08-18 - Projekte an verschobene Library angepasst - Libraryverweis auf ft232rl entfernt (hinfällig, da Bauteil in Custom-Bibliothek verschoben)
2016-08-18 -Anforderungen Tabelle hinzugefügt
2016-08-21 - 4-Weg Kreunzungen entfernt - 3V3 und 5V an allen Zusatzanschlüssen vorgesehen - Ferrit zur Entkopplung zwischen GND-GNDA und VDD-VDDA vorgesehen - Ansteuerung TEN 30-1212 überarbeitet
2016-08-28 - Restliche Footprints hinzugefügt und verknüpft
2016-08-29 - RC-Glieder an ADC hinzugefügt - Wannenstecker mit Spannungsversorgung an Op-Amps hinzugefügt - 0R Widerstände an Op-Amp Ausgängen hinzugefügt
2016-08-30 - Layout Grob sortiert - Fehler an CAR-ID DIP behoben(Pin Zuordnung Fehlerhaft) - Fehler an GNDD behoben (GNDA und GNDD vertauscht an TEN30)
2016-08-31 - Layout fortgesetzt
2016-09-01 - RC-Glieder im Schaltplan hinzugefügt - LED4 Hinzugefügt
2016-09-01 - Layout Schalterplatine ohne Routing
2016-09-02 - BATT2_IN Doppelt belegt - LDO Regler ausgetauscht
2016-09-05 Datenblätter STM32 und DCDC-Wandler TEN 30 hinzugefügt
2016-09-05 Projektdatei für STM32CubeMX hinzugefügt
2016-09-05 Datenblatt EEPROM hinzugefügt
2016-09-05 - TIM20_CH1 und CH2 mit TIM1_CH3 und CH4 ersetzt - WAGO713_1403 (grade) mit WAGO_713-1423 (gewinkelt) ersetzt - Footprint TEN30 angepasst um Platz für Kühlkörper zu lassen - Routing Fortgesetzt
2016-09-05 Datenblatt PMOS hinzugefügt
2016-09-05 Registerbeschreibung MPU hinzugefügt
2016-09-06 Workspace-Verzeichnis für "System Workbench for STM32" (eclipse) erstellt
2016-09-06 - "Index unused headers" deaktiviert, damit kein Fehler bei SysTick_IRQn angezeigt wird
2016-09-06 Latex-Projekt zur Dokumentation begonnen
2016-09-06 - Sperrflächen verschoben
2016-09-06 - Genauere Definition der Bauteil-Pins (Eingang, Ausgang, Bidirektional, Spannungseingang, Spannungsausgang) - Power-Flags neu gesetzt.
2016-09-06 - Versorgungsspannung verbunden - Lötjumper für MPU_INT vorgesehen
2016-09-07 - ERC fehler behoben
2016-09-07 - Lötstoppmaske angepasst - Durchkontaktierung für Masseverbindung hinzugefügt
2016-09-07 - Footprint TEN30 korrigiert
2016-09-07 - Alle Elemente verbunden
2016-09-07 - Beschriftung zusätzliche spannungsversorgungen
2016-09-07 - Masseflächen stärker verbunden
2016-09-09 Beschriftungstext auf Unterseite gespiegelt
2016-09-09 - Pinzuordnung bei Winkelstecker geändert - Platinenbezeichnung in Kupfer eingebettet
2016-09-09 - Steckerbelegungen als Bestückungsdruck - Platinenbezeichnung in Kupfer geschrieben
2016-09-09 Bauteilbezeichnungen ergänzt
2016-09-09 Steckerbelegungen auf Bestückungsdruck vervollständigt
2016-09-09 Fertigungsdaten erzeugt
2016-09-09 "Schalter_Fahrakku" in "drvbatswitch" umbenannt
2016-09-09 ucboard-rescue.lib gelöscht und Referenz aus Projekt gelöscht. (Hatte nur eine Rescue-Version des MPU9250 enthalten, der im Schaltplan nicht verwendet wurde.)
2016-09-13 - Teilelisten aktualisiert - Exceldokument "Bestellisten.xlsx" in Verzeichnis doc aufgesetzt
2016-09-14 - Bestellisten bis auf Spulen/Ferrite zur Entkopplung vervollständigt - Oberer Widerstand im Spannungsteiler an 7,2V von 16k auf 14k Reduziert (7,5V -> 3,3V)
2016-09-14 - Bestelliste Ferritperle hinzugefügt
2016-09-15 extern-Verweis auskommentiert, um Warnung zu vermeiden
2016-09-15 stopwatch hinzugefügt (TIM15->TIM20)
2016-09-15 stdtypes hinzugefügt
2016-09-16 UNUSED in UNUSEDARG umbenannt, wegen doppelter Definition
2016-09-16 Eigene Low-Level-Macros in stm32_llm ausgelagert.
2016-09-16 (Leere) Dateien für Treiber Sensoren/Aktoren hinzugefügt.
2016-09-18 stmcommon und devices zu Include-Pfaden hinzugefügt
2016-09-18 Datenblatt Ultraschallsensor hinzugefügt
2016-09-18 ARingbuffer hinzugefügt
2016-09-18 debug.h hinzugefügt (noch "leere" Makros)
2016-09-18 stm32f3xx_hal_i2c.h in Headerdatei included, damit alle Verwender diese automatisch auch includen (und damit die Definitionen der Konstanten für die Einstellungen haben)
2016-09-18 ringbuffer hinzugefügt
2016-09-18 leere Dateien für Ultraschallverwaltung hinzugefügt (usonic)
2016-09-18 Datei für Session-ID hinzugefügt
2016-09-20 [wip] Arbeit an Kommunikationsstack
2016-09-23 - Funktion atoi hinzugefügt - wait_us und wait_ms entfernt. Damit wird auch Stopwatch.h nicht mehr eingebunden, und es muss nicht stm32f3xx.h vor common_fcts.h included werden.
2016-09-23 Test für Taster und LEDs in systick
2016-09-24 Optimierungsstufe auf o3
2016-09-24 Initroutinen Comm und Display in main.c
2016-09-26 - Wert von R3 von 0R auf n.B. geändert
2016-09-27 Batch-Datei zum Flashen hinzugefügt
2016-09-27 Funktionalität zum Schalten des 12V-Ausgangs hinzugefügt
2016-09-28 Befehl TICS hinzugefügt
2016-09-28 display_printerror hinzugefügt
2016-09-28 kleinere Änderungen
2016-09-28 - Verschiedene Änderungen - mit MPU angefangen
2016-09-29 Konfiguration angepasst
2016-09-30 gemeinsames Abfragen aller US-Sensoren
2016-09-30 Für mögliche Fehler der USART3 die Interruptflags zurücksetzen, damit sich uC nicht aufhängt, wenn RS232 im Betrieb an- und ausgeschaltet (bzw. an- und abgesteckt) wird.
2016-10-02 (Sende)-Puffer robuster gemacht
2016-10-02 DAQ: ALL und ANY implementiert
2016-10-02 DAQ: Encoding und CRC hinzugefügt
2016-10-02 Bug in Display-Stream beseitigt (Rückgabewert *pbMsgComplete wurde nicht in allen Pfaden gesetzt.)
2016-10-02 IMU aufgeräumt und Abfrage aller Werte (noch keine Magnetometerwerte!)
2016-10-03 Arbeit an Dokumentation der Kommunikation
2016-10-04 Einheit US-Messwerte in 0.1mm geändert
2016-10-04 Werte von DTICS16 und DTICS8 gesättigt
2016-10-04 250 ms-Pause vor MPU-Init. (MPU braucht wohl eine gewisse Zeit, nach Einschalten der Spannungsversorgung einsatzbereit zu sein.)
2016-10-04 Arbeit an Dokumentation
2016-10-04 Auswertung Hall-Sensor über Interrupt.
2016-10-07 Hall-Sensor auf PE15 umgestellt. (Entsprechender Pull-up zwischen Steckerpins eingelötet, C24 ausgelötet.)
2016-10-07 Anpassen Schaltplan an aktuelle Bestückung: - R22: 56k anstelle 14k - C24: n.B. anstelle 470n - R68: 10k Pull-up für Hallsensor hinzugefügt
2016-10-08 Befehl VER hinzugefügt (Ausgabe Versionsstring)
2016-10-08 - spimgr um Funktionen für 8bit-Frames erweitert. - imu-Kommunikation auf 8bit-Frames umgestellt
2016-10-08 pkg -> grp umbenannt
2016-10-11 Abtastrate US-Sensoren erhöht (auf ca. 45 ms)
2016-10-11 - Verkleinerung des DAQ-Buffers - Setzen des "letzten Datensatzes" der Gruppenkanäle bei Starten der Datenerfassung auf aktuellen Tic-Wert - 1, so dass keine alten Daten verschickt werden.
2016-10-11 DAQ: Erste Version Ausgabe Gruppeninformationen (?DAQ GRP)
2016-10-11 neuer env-hash
2016-10-16 Abschnitt Kommunikation umgestellt
2016-10-16 - Ausgabe von Gruppeninfos aller aktiven Gruppen mit ?DAQ GRPS, Ausgabe von speziellen Gruppen mit ?DAQ GRP nb - Korrekte Behandlung von Specialchannels bei Generierung der Gruppeninfo
2016-10-16 Funktionen zum Löschen, Deaktivieren und Aktivieren von Gruppen hinzugefügt
2016-10-16 Samplingmodus TS hinzugefügt
2016-10-16 CKonfiguration wird neu an US-Sensoren geschickt, wenn der Wert 0 als Messwert zurück kommt. (Irgendwie scheint sich der Sensor damit immer auf die Startwerte zurückzusetzen.)
2016-10-16 Filter IMU eingestellt
2016-10-16 Dokumentation Kommunikation angepasst
2016-10-17 - Gruppenweise DAQ-Puffer eingeführt: Es wird nur noch jeweils die aktuelle Abtastung einer Gruppe übertragen. - Sonderkanäle _DLY, _DLY16 und _DLY8 hinzugefügt
2016-10-17 Abprüfen, dass maximale Anzahl an Gruppenkanälen nicht überschritten wird
2016-10-17 Funktionialität zum messen der maximalen SysTick-Zeit (auskommentiert)
2016-10-17 Option ~AVG hinzugefügt
2016-10-17 *.toc ignoriert
2016-10-18 Versionsstring geändert
2016-10-18 Korrektur/Anpassungen Dokumentation
2016-10-20 LED_A_ON() bei Datenempfang über RS232-UART enfernt
2016-10-21 stlinkflash.bat ignoriert, dafür stlinkflash_template.bat als Vorlage hinzugefügt
2016-10-21 Aktuellen Stand der Dokumentation als PDF in Hauptverzeichnis
2016-10-24 Befehl !STEER und ?STEER geben jetzt die Stellwerte ([-1000, 1000]) und nicht die daraus berechneten "PWM-Werte" ([-500, 500]) zurück.
2016-10-25 Release zur Version 0.9.0 erstellt.
2016-10-25 Änderung bei Projekteinstellung
2016-10-25 PDF mit aktueller Version des Schaltplans hinzugefügt.
2016-10-25 Richtungsangabe y-Achse IMU in Dokumentation korrigiert
2016-10-31 ucterm hinzugefügt: Einfaches Terminalprogramm in C# (Windows) zum Testen des ucboards
2016-10-31 Totmannschaltung für DRV implementiert
2016-10-31 - Anzeigen der Daten über einen Timer realisiert, um Einfrieren bei großen Datenmengen zu vermeiden - Kleinere Änderungen am Format
2016-11-01 - Bug beseitigt: Display-Daten wurden in DAQ-Feld geschrieben - Versionierung begonnen: 1.0.0
2016-11-01 Version auf 0.9.1 gesetzt
2016-11-01 Hinweis zur IDE hinzugefügt
2016-11-01 Funktionalität des Befehls US beschrieben.
2016-11-01 Aktuelle Version ucboard.pdf
2016-11-03 Bug in isInteger korrigiert
2016-11-03 Befehl IMU zurm Einstellen und Abfragen der Sensorkonfiguration hinzugefügt
2016-11-03 STEER: Behandlung der doppelten Übertragung des Wertes hinzugefügt
2016-11-03 Dokumentation zur doppelten Übertragung des STEER-Wertes schwarz geschrieben
2016-11-03 Release 0.10.0 hinzugefügt
2016-11-07 GFILT: Alle Einstellungen des Sensor unterstützt ([-2, 7])
2016-11-07 Erläuterungen zu Filtereinstellungen ergänzt
2016-11-07 Spannungsversorgung Kinect standardmäßig ein
2016-11-07 Version auf 0.10.1 gesetzt
2016-11-07 Anleitung von Nicolas Acero für Flashen unter Linux integriert
2016-11-26 Name korrigiert
2016-11-26 Umbenennung Datenblatt
2016-11-26 [wip] Inbetriebnahme Magnetometer
    [wip] Inbetriebnahme Magnetometer
    Andere Achsenorientierung Magnetometer gegenüber IMU berücksichtigt
    Magnetometer in Betrieb genommen. !MAG OPT USEASA und ?MAG ASA hinzugefügt
    Magnetometer: Overflow-Bit in ST2 berücksichtigt und Kanalbeschreibung vervollständigt
2016-11-26 Beschreibung Magnetometer
2016-11-26 Version auf 0.11.0 gesetzt
2016-11-26 Version 0.11.0 beschrieben
2016-11-26 Roadmap hinzugefügt
2016-12-08 Kleinere Korrekturen
2017-11-03 .vs-Verzeichnis von VisualStudio 2017 ignoriert
2017-11-05 - TRUE/FALSE -> true/false - Macro _INLINE for "Forced-inline" added - NULL defined as (void*)0
2017-11-06 - Wait for answer after message is sent (moved from before the message is sent) - Set VersionString to 1.0.1
2017-11-07 Datasheet MPU-9250 added
2017-11-07 - accounting for that the EOT-marker length is currently 2, i.e. EOT + \n (and not just 1)
2017-11-09 pep8-ified
2017-11-09 create embitz-project for parallel use (for debugging purposes)
2017-11-09 xml-file updated by System Workbench
2017-11-09 - Bug fixed: - Check if ORE is set and reset it if that is the case. (ORE is active if either RXNEIE or EIE is set. This caused infinity calls to the irq handler if one ORE event occurs.) - All unuse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
2017-11-09 Version 0.11.1 beschrieben
2017-11-09 script to send data w/o waiting for answers (for debug purposes)
2017-11-13 List of used and free resources added in documentation.
2017-12-13 - i2cmgr: Reset any error flag before exiting isr. - debug-command added
2017-12-13 release 0.11.2 added
2017-12-13 current version of ucboard.pdf
2018-02-14 - UART3 deaktiviert
2018-02-14 Feststellen, welche US-Device nicht initialisiert werden konnten und diese nicht weiter abfragen
2018-02-14 release 0.11.3 added
2018-02-16 function i2cmgr_removeDevice added
2018-02-16 changed some parameters to "const"
2018-02-16 set version to 0.11.4
2018-02-16 commands US PING and US CHGADDR described
2018-02-16 small addition
2018-05-15 Spezifikation D1-D6, L2+L3 nachgetragen
2018-05-15 Spezifikation D1 nachgetragen.
2018-05-20 Änderung der beim Öffnen eingeblendeten Layer
2018-07-13 Maximale Anzahl der Parameter/Optionen eines Befehls von 20 auf 22 erhöht.
2018-07-13 Implementierung der LED- und Taster-Funktionalität
2018-07-13 change in message format from ucboard described: all messages from ucboard start with \02 (STX)
2018-07-13 new message format implemented: all messages from ucboard start with \02 (STX)
2018-07-13 change in daq-data format implemented
2018-07-13 set version to 0.12.0
2018-07-13 version 0.12.0 described
2018-07-22 Bestückungsdruck korrigiert: R20 <=> R66
2019-02-15 - tabs replaced by four spaces - trailing whitespaces removed

Notices in the files:
fw_workspace/pses_ucboard/Src/stm32f3xx_hal_msp.c:
COPYRIGHT(c) 2016 STMicroelectronics
(C) COPYRIGHT STMicroelectronics *****END OF FILE
